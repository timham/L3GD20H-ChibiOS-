# IAR project TS_SPI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: .\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: TS_SPI.out
  ILINK.IlinkIcfFile: TS_SPI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c i2s.c icu.c mac.c mmc_spi.c mmcsd.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c tm.c uart.c usb.c
    ../../../os/hal/platforms/STM32F30x/: adc_lld.c adc_lld.h ext_lld_isr.c ext_lld_isr.h hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h stm32_isr.h stm32_rcc.h stm32f30x.h
    ../../../boards/ST_STM32F3_DISCOVERY/: board.c board.h
    ../GYRO/: L3GDInitChi.c
    ./: main.c
